Commit message: lowered mass of glass

File: gym_baxter_grabbing/envs/glass_urdf.urdf (robot description, URDF)
Before this commit: robot glass, 1 links, 0 joints
Links:
- link base_link: mass 1 -> 0.2
